# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL,STM32F401xx
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM;..\HARDWARE;..\UCOS_CONFIG;..\UCOS_CORE;..\UCOS_PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Core
    ../CORE/: startup_stm32f401xx.s
  group Sys
    ../SYSTEM/: Delay.c
  group FWLIB
    ../SYSTEM/: Delay.h
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Hardware
    ../HARDWARE/: MyI2C.c MyI2C.h MPU.c MPU.h MPU6050Adress.h HMC5883L.c HMC5883L.h HMC5883LAdress.h Serial.c Serial.h Receiver.c Receiver.h Moter.c Moter.h
  group UCOS_CONFIG
    ../UCOS_CONFIG/: os_cfg.h app_cfg.h app_hooks.c
  group UCOS_CORE
    ../UCOS_CORE/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h os.h os_trace.h
  group UCOS_PORT
    ../UCOS_PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
